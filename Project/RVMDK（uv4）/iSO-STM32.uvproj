# Keil uVision project iSO-STM32.uvproj, settings and files
target USART1（interrupt） (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\TimBase;..\..\User\modbus;..\..\User\SysTick;..\..\User\gprs;..\..\User\rtc;..\..\User\WatchDog;..\..\User\Aider_Data_Protocol;..\..\User\Flash;..\..\User\433_Wiminet;..\..\User\433_Wiminet\Message;..\..\User\433_Wiminet\Platform;..\..\User\common;..\..\User\DS2780;..\..\User\ch4sensor;..\..\User\test;..\..\User\test;..\..\User\ADC;..\..\User\ADC;..\..\User\433_Wiminet;..\..\User\SensorInit;..\..\User\SensorInit;..\..\User\SensorInit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/usart/: bsp_usart.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/gprs/: gprs.c
    ../../User/rtc/: bsp_rtc.c bsp_date.c
    ../../User/WatchDog/: WatchDog.c
    ../../User/Aider_Data_Protocol/: AiderProtocol.c
    ../../User/Flash/: Flash.c
    ../../User/433_Wiminet/Platform/: API-Platform.c
    ../../User/common/: common.c
    ../../User/DS2780/: DS2780.c
    ../../User/modbus/: modbus.c
    ../../User/test/: test.c
    ../../User/ADC/: sensor-adc.c
    ../../User/433_Wiminet/: 433_Wiminet.c
    ../../User/SensorInit/: SensorInit.c
  group DOC
    ../../Doc/: readme.txt 修改说明.txt Modbus_RTU协议解析.txt
